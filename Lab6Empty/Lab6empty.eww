<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\Lab6\lab6.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Lab6emptyyyyyyyy.ewp</path>
    </project>
    <batchBuild />
</workspace>
